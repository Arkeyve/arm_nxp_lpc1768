	AREA mycode,CODE,READONLY
		EXPORT __Vectors
__Vectors
	DCD 0X40001000;
	DCD Reset_Handler
	ALIGN
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R6,=Result
	LDR R1,[R0],#4
	LDR R2,[R0]
	SUBS R3,R2,R1
	SBC R4,#0
	CMP R4,#0
	BEQ DOWN
	STR R3,[R6]
DOWN CMP R4,#0
     BEQ D
D   
	MOV R7,#0
	SUBS R3,R7,R3
	STR R3,[R6]
	
STOP
	B STOP
SRC DCD 0X00000028,0X00000019
	AREA DATASEG,DATA,READWRITE
Result DCD 0
 END