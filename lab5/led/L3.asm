	AREA mycode,CODE,READONLY
		EXPORT __Vectors
__Vectors
	DCD 0X40001000;
	DCD Reset_Handler
	ALIGN
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R5,=Result
	MOV R1,#5
	MOV R2,#1
LOOP MOV R3,R2
	 MOV R4,R3
DOWN ADDS R6,R3
	 ADC R7,#0
	 SUB R4,#1
	 CMP R4,#0
	 BNE DOWN
	 ADDS R8,R6
	 ADC R9,R7,#0
	 SUB R6,R6
	 ADD R2,#1
	 SUB R1,#1
	 CMP R1,#0
	 BNE LOOP
	 STR R8,[R5],#4
	 STR R9,[R5]
STOP
	B STOP
SRC DCD 0X12345678
	AREA DATASEG,DATA,READWRITE
Result DCD 0,0
 END